# Keil uVision project STM32H750XBH_ARTPIQSPI_W25Q64JV.uvprojx, settings and files
target STM32H750XBH_ARTPIQSPI_W25Q64JV (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32H750XBHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00020000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: STM32H750XBH_ARTPIQSPI_W25Q64JV
  AfterMake: cmd.exe /C copy "!L" "D:\RT-ThreadStudio\workspace\ARTPI_XU_Demo\board\stldr\STM32H750XBH_ARTPIQSPI_W25Q64JV.stldr"
  AfterMake: cmd.exe /C copy "!L" "..\STM32H750XBH_ARTPIQSPI_W25Q64JV.stldr"
  c flags: Optim=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32H750xx
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;..\..\flashalgo_stldr
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: ..\loader.sct
  link misc: --diag_suppress L6305
  group Application/User/Core
    ../Core/Src/: main.c quadspi.c stm32h7xx_it.c stm32h7xx_hal_msp.c w25qxx.c usart.c
    ../: Dev_Inf.c Loader_Src.c w25q64jvx.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_qspi.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_dma.c stm32h7xx_hal_mdma.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
software components: CMSIS:CORE 5.6.0
